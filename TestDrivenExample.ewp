# IAR project TestDrivenExample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration TDD (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TDD
  ICCARM.CCIncludePath2: ..\Unity; C:\Embedded\Test Driven Devlopment\Unity\extras\fixture\src; C:\Embedded\Test Driven Devlopment\Unity\src; C:\Embedded\Test Driven Devlopment\Unity\extras\memory\src
  group (top)
    ./: dumb.c dumb.h main.c
  group Tests
    ./: AllTest.c dumbTest.c
  group Unity
    Unity/src/: unity.c unity.h unity_internals.h
    Unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h
